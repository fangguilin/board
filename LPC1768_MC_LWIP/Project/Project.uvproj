# Keil uVision project Project.uvproj, settings and files
target LPC1768_MC (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c include: ..\ExtiDrive;..\lwip-1.3.1\port;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip;..\Cmsis;..\App
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Cmsis
    ../Cmsis/: core_cm3.c startup_LPC17xx.s system_LPC17xx.c
  group App
    ../App/: main.c LPC17xx_it.c TCP_server.c
    ../ExtiDrive/: netconf.c
  group DriveBase
    ../ExtiDrive/: emac.c uart.c LCD1602.c MAX485.c
  group lwip
    ../lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/src/netif/: etharp.c
    ../lwip-1.3.1/port/: ethernetif.c
  group Doc
    ../Doc/: ReadMe.txt
